File: logic/mcu.kicad_sch (KiCad schematic)
At the start: 46 parts, among them U14 STM32G473VCTx

Commit message: start
Parts:
- gave numbers to parts that had none: 1
