File: logic/logic_4850.kicad_sch (KiCad schematic)
At the start: 19 parts

Commit message: start
Parts:
- gave numbers to parts that had none: 19
