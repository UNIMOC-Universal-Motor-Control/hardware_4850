File: logic/phase.kicad_sch (KiCad schematic)
At the start: 57 parts

Commit message: start
Parts:
- gave numbers to parts that had none: 1
